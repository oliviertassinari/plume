# IAR project spi_master_example.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: NRF51822 Nordic Semiconductor NRF51822
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; NRF51
  ICCARM.CCIncludePath2: ..\..\..\..\Include; ..\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: spi_master_example_iar.hex
  ILINK.IlinkOutputFile: spi_example_example_iar.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../../../Source/templates/iar/: iar_startup_nrf51.s
    ../: main.c
    ../../../../Source/nrf_delay/: nrf_delay.c
    ../../../../Source/spi_master/: spi_master.c
    ../../../../Source/templates/: system_nrf51.c
